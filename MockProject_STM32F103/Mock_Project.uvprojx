# Keil uVision project Mock_Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mock_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ./: main.c STM32F1XX.h
  group APP_FUNCTION
    ./: APP_FUNCTION.c APP_FUNCTION.h
  group UART
    ./: UART.c UART.h UART_Register.h
  group SPI
    ./: SPI.c SPI.h SPI_Register.h
  group TIMER
    ./: TIMER.c TIMER.h TIMER_Register.h
  group NVIC
    ./: NVIC.c NVIC.h NVIC_Register.h
  group CLOCK
    ./: CLOCK.c CLOCK.h CLOCK_Register.h
  group GPIO
    ./: GPIO.c GPIO.h GPIO_Register.h
  group Softtimer
    ./: Softtimer.c Softtimer.h Systick_Register.h
  group LED_MAX7219
    ./: LED_MAX7219.c LED_MAX7219.h
  group String
    ./: String.c String.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
